options:
  parameters:
    author: j
    generate_options: qt_gui
    id: spectrum_an_wav
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/j/src/signal_processing/010_audio_compression/7na.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/j/src/signal_processing/010_audio_compression/compressed_signal.wav
    repeat: 'True'
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: '1'
    showrf: 'True'
    type: float
  states: {}

connections:
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
